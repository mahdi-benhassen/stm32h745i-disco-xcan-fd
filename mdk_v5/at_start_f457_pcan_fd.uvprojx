# Keil uVision project at_start_f457_pcan_fd.uvprojx, settings and files
target at_start_f457_pcan_fd (6240000::V6.24::ARMCLANG)
  device: AT32F457ZET7 ArteryTek
  pack: ArteryTek.AT32F45x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at_start_f457_pcan_fd +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F457ZET7,USE_STDPERIPH_DRIVER,AT_START_F457_V1,SUPPORT_CAN_FD,PCAN_PRO_FD=1,INCLUDE_LIN_INTERFACE=1
  c include: ..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\libraries\drivers\inc;..\middlewares\usb_drivers\inc;..\board;..\app;..\app\pcan
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group app
    ../app/: main.c at32f45x_clock.c at32f45x_int.c
  group pcan
    ../app/pcan/: pcan_usb_device.c pcan_usbd_desc.c pcanpro_can.c pcanpro_fd_protocol.c pcanpro_led.c pcanpro_timestamp.c pcanpro_usbd.c
  group board
    ../board/: at32f45x_board.c
  group drivers
    ../libraries/drivers/src/: at32f45x_can.c at32f45x_crm.c at32f45x_exint.c at32f45x_flash.c at32f45x_gpio.c at32f45x_misc.c at32f45x_pwc.c at32f45x_scfg.c at32f45x_tmr.c at32f45x_usart.c at32f45x_usb.c
  group usbd_driver
    ../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f45x.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f45x.s
